# Repository rimuadmin/TeensyMaestro-Hardware

File README.md:

# TeensyMaestro Front Panel and PCB

### What Is TeensyMaestro?
The TeensyMaestro is a custom-built hardware controller first designed by Len (KD0RC) to interface with FlexRadio transceivers - specifically models in the 6000 and 8000 series. It performs some, but not all, of the common functions that the SmartSDR app or the Flex Maestro perform. The name TeensyMaestro comes from its core component: the Teensy 4.1 microcontroller, which powers the device. Len's initial version was built using point-to-point wiring which presented a challenge for builders. Len (KD0RC) and Simon (NV0E) have created a PCB and matching front panel that simplifies the build process. 

### What Is This Project?
This repository describes the version 2 PCB and Front Panel hardware. The intent of this PCB is to simplify the build process, make it easier to produce a polished final product, and replace some components with less expensive alternatives. It has detailed instructions that describe how to order parts, build and assemble a TeensyMaestro using the version 2 hardware.

The documentation for building the PCB and Front panel is here: 

[TeensyMaestro Hardware Wiki](https://github.com/rimuadmin/TeensyMaestro-Hardware/wiki)

Len's firmware that supports all versions is available here:

[TeensyMaestro for Flex 6000 Radios](https://github.com/KD0RC/Teensy-Maestro-for-Flex-6000-radios)

Len's GitHub page has a detailed user manual that explains how to operate the TeensyMaestro and build instructions for version 1.

## KiCad design TeensyMaestro Main PCB/TeensyMaestro Main PCB.kicad_pcb

File TeensyMaestro Main PCB/README.md (part):

# PCB for the TeensyMaestro

## Summary
The TeensyMaestro was first designed by Len (KD0RC) to connect to a FlexRadio model 6000 or 8000. It performs some, but not all, of the common functions that the SmartSDR app or the Flex Maestro perform. It's named TeensyMaestro because it's designed around the Teensy 4.1 Microcontroller. Len's initial version was built using point-to-point wiring which presents a challenge for builders. Len and I (NV0E) have created a PCB and matching front panel that simplifies the build process. Len's project describing hardware version 1 and containing the firmware for all versions is here:

[TeensyMaestro for Flex 6000 Radios](https://github.com/KD0RC/Teensy-Maestro-for-Flex-6000-radios)

The intent of this PCB is to simplify the build process, make it easier to produce a polished final product, and substitute some components for less expensive alternatives.

Associated Projects:
- [TeensyMaestro Main PCB (this project)](https://github.com/rimuadmin/Teensy_Maestro-hw)
- [TeensyMaestro Front Panel](https://github.com/rimuadmin/Teensy_Maestro_Front_Panel-hw)
- [TeensyMaestro for Flex 6000 Radios (the firmware)](https://github.com/KD0RC/Teensy-Maestro-for-Flex-6000-radios)

## Design Features
- A main PCB that simplifies building the Teensy Maestro and minimizes wiring errors.
- A front panel that matches the main PCB that can be fabricated by a PCB manufacturer in aluminum. This inexpensive option will allow a builder to achieve a refined, professional finish.
- Through-hole components to simplify assembly.
- PCB headers to connect to the rear panel connectors.
- I2C bus header for future extensibility.
- Optocoupler on key-out connector for electrical isolation from the radio.
- Reduced BOM cost due to part substitution.

## Front Panel
- The holes and openings align with the encoders, switches and LCD of the main PCB.
- The front panel can be fabricated in aluminum and ordered from the same PCB fabricator as the main PCB. 
- Our recommendation is to order a black aluminum front panel with white text. This costs a little more than FR4, but creates a professional looking project.
- Here is a link to the Front Panel repository: [TeensyMaestro Front Panel](https://github.com/rimuadmin/Teensy_Maestro_Front_Panel-hw)

## Circuit Differences from Original Design
- **Multiplexers (CD74HC5067M) → I2C I/O Expanders (MCP23008/MCP23017)** - This frees up some GPIOs on the Teensy for other uses.
- **Adafruit LCD (HX8357D) & Touch Controller (TSC2007) → ST7796S LCD** - The new LCD has an integrated touch controller, reducing cost from ~$45 to ~$19. It's also slightly larger (4.0" vs. 3.5”) but retains the same 480x320 resolution.
- **Panel-Mounted Switches → PCB-Mounted Switches** - The 4 panel mounted switches (RIT-A, XIT-A, RIT-B, XIT-B) are now directly mounted on the PCB.
- An optocoupler has been added to the KEY OUT for electrical isolation between the TeensyMaestro and the radio.

## Ordering the PCB from JLCPCB
1. Download the zip file (production/TeensyMaestro_Main_PCB_3.0.zip) from this repository to your PC
2. Open JLCPCB's web page (jlcpcb.com) in a browser
3. Click 'Order Now'
4. Use the 'Add gerber file' button to select the zip file that you downloaded
5. The order page will import the gerber files and you should see the 2D representation of the front and rear of the panel displayed.
6. JLCPCB examines the zip file and sets the Layers and Dimensions values.
7. The default quantity is 5, the minimum order quantity.
8. The remaining defaults don't need to be changed, but if you prefer a different color PCB you could select it here.
9. Optionally, select 'Surface Finish: LeadFree HASL'
10. Click 'Save to Cart'.
11. Don't forget to add the Front Panel to the same order to save money on shipping costs.

## Overall Assembly
- The slice tuning encoders are attached directly to the front panel, with openings in the main PCB to allow the encoders to pass through.
- The front side of the PCB holds the display, encoders and push buttons.
- The reverse side of the PCB holds the Teensy 4.1 micro controller, I/O Expanders, header connectors, resistors and capacitors.

# PCB Assembly Steps

> *Do not solder the display on to the front side of the PCB until all the components on the rear side of the PCB have been soldered. The display covers over component through-holes that can't be soldered after the display is in place.*

### 1. Prepare the Display

#### 1a. Remove the SD Card Holder from the Display
Designing the PCB so that all the required through-hole components fit on the PCB required that we use all the available space. The SD Card holder on the display is not used in this circuit so there is no need for it to remain attached to the display. The through-hole component leads from the rear of the PCB will short against the metal cover if it's not removed. Additionally, if the SD Card holder is not removed, special care must be taken to not cause the display to tilt or sit unevenly. This misalignment makes it harder to get the front panel to fit flush. Removing the SD Card holder makes leveling easier.

**Steps to Remove the SD Card Holder:**
1. **Apply Flux** - Dab a small amount of flux on the joints to improve heat transfer and help the solder flow into the braid.
2. **Add Solder to the Joints** - Reflow the existing joints by adding a small amount of fresh solder to each one.
3. **Use Solder Wick** - Use solder wick to absorb the molten solder from each joint.
4. **Remove the Metal Cover** - While heating the corner joints with a soldering iron, gently pry up the metal cover of the SD card holder using tweezers. Don't apply excessive force or the solder pads will lift off the FR4 PCB material.
5. **Detach the Plastic Connector** - With the cover off, continue heating the pins while using tweezers to lift the plastic connector. 
6. **Clean the Area** - Use isopropyl alcohol and Q-tips to clean off any remaining flux or residue from the PCB.

#### 1b. Solder 4 Pin Header to Display
This 4-pin header is not used by the circuit, but must be added to provide mechanical support for the display on the PCB.

1. Count and mark a 4-pin section of a header strip.
2. Cut cleanly between the 4th and 5th pins.
3. Smooth edges with a file or sanding block if sharp or uneven.
4. Solder the 4 pin header to the left side of the display.
5. The pin headers on each side should now be the same height.

The SD Card holder has been removed and the 4 pin header soldered:

### 2. Solder Male Headers to the Teensy 4.1

#### 2a. Prepare Two 24-Pin Headers for the Long Sides
1. Count and mark two 24-pin sections on a header strip.
2. Cut cleanly between the 24th and 25th pins.
3. Smooth edges with a file or sanding block if sharp or uneven.
4. Repeat for the second 24-pin header.

#### 2b. Create a 5-Pin Header for GND, PROG, and ON/OFF Pins
1. Count and cut a 5-pin section.
2. Check alignment: These 5 pins go on the short side of the Teensy, opposite the USB connector (above the SD card slot area).
3. Clean up the cut edge if needed.

#### 2c. Create a 1-Pin Header for VUSB
1. Cut a single pin from the strip.
2. Use pliers to gently remove any excess plastic or bent pins.

#### 2d. Solder Male Headers to the Teensy 4.1

### 3. Prepare Female Headers for the Teensy 4.1

#### 3a. Cut Two 24-Pin Female Headers
1. Count 25 pins on a header strip.
2. Cut on the 25th pin using side cutters. This preserves 24 usable sockets in the segment before the cut.
3. Trim plastic burrs from the cut end using a file or sandpaper if needed.
4. Repeat to create a second 24-pin female header.
5. Dry fit both on the long edges of the Teensy to verify alignment.

#### 3b. Cut a 5-Pin Header for GND, PROG, ON/OFF
1. Count 6 pins and cut on the 6th pin—this gives you a 5-socket segment.
2. Inspect and clean the edges to ensure all 5 sockets are usable.
3. This header will align with the 5-pin row near the SD card slot, opposite the USB port.
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
Board: 2 copper layers, 197.3 x 121.2 mm, 114 parts (94 on the bottom side), 78 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C43, C44, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63, C64, C65: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C9, C10, C25, C26: 1nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.5mm_Pad
J2, J4: B5B-XH-A_LF__SN_; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J16, J17, J18, J19, J20, J21, J26, J27, J35: B2B-XH-A_LF__SN_; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J22: B3B-XH-A_LF__SN_; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J28: B4B-PH-K-S_LF__SN_; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J36, J37: Conn_01x10; JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
R1, R2, R3, R4: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R8: 4K7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
S1, S2, S3, S4: 1825910-6; 3ETH9120
SW2, SW3, SW9, SW10: PEC11L-4120F-S0020; PEC11L4115FS0020_NR
SW4, SW5, SW7, SW8: PEC11L-4120F-S0020; PEC11L4115FS0020_VNR
SW11: PEC11L-4120F-S0020; PEC11L4115FS0020
TP1: 5V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP2: 3V3; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP3: GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U1: DEV-16771; MODULE_DEV-16771
U2: MSP4021-ST7796S; MSP4021-ST7796S-TM
U3: LTV-817; DIP-4_W7.62mm
U4, U5: MCP23008-xP; DIP-18_W7.62mm
U7: MCP23017-E_SP; DIP-28_W7.62mm_Socket_LongPads

Connections:
+3V3: C46.1, C47.1, C48.1, J28.2, R7.2, R8.2, TP2.1, U1.3.3V_2 (3.3V__1), U4.6 (~RESET), U4.18 (VDD), U5.5 (A0), U5.6 (~RESET), U5.18 (VDD), U7.9 (VDD), U7.16 (A1), U7.18 (~RESET)
+5V: J2.4, J4.4, R1.1, R2.1, R3.1, R4.1, TP1.1, U1.VUSB, U2.1 (VCC)
/IO Expander A/IOX_A_AGC-T1: C16.1, SW5.A, U1.24 (A10)
/IO Expander A/IOX_A_AGC-T2: C14.1, SW5.B, U1.25 (A11)
/IO Expander A/IOX_A_HIGH_WIDTH1: C15.1, SW4.A, U1.6 (OUT1D)
/IO Expander A/IOX_A_HIGH_WIDTH2: C13.1, SW4.B, U1.7 (RX2)
/IO Expander A/IOX_A_LOW_SHIFT1: C8.1, SW3.A, U1.4 (BCLK2)
/IO Expander A/IOX_A_LOW_SHIFT2: C6.1, SW3.B, U1.5 (IN2)
/IO Expander A/IOX_A_MUTE: C1.1, SW2.S1, U4.10 (GP0)
/IO Expander A/IOX_A_NB: C2.1, SW3.S1, U4.12 (GP2)
/IO Expander A/IOX_A_NR: C11.1, SW4.S1, U4.13 (GP3)
/IO Expander A/IOX_A_PhaseA: C9.1, J2.1, R1.2, U1.0 (RX1)
/IO Expander A/IOX_A_PhaseB: C10.1, J2.5, R2.2, U1.1 (TX1)
/IO Expander A/IOX_A_RIT: C3.1, S1.2, U4.14 (GP4)
/IO Expander A/IOX_A_RIT_SEL: C12.1, SW5.S1, U4.11 (GP1)
/IO Expander A/IOX_A_VOL1: C7.1, SW2.A, U1.2 (OUT2)
/IO Expander A/IOX_A_VOL2: C5.1, SW2.B, U1.3 (LRCLK2)
/IO Expander A/IOX_A_XIT: C4.1, S2.2, U4.15 (GP5)
/IO Expander A/MENU_SEL: C33.1, SW11.S1, U4.16 (GP6)
/IO Expander A/TFT_LED: R5.2, U4.17 (GP7)
/IO Expander B/IOX_B_AGC-T1: C32.1, SW10.A, U1.26 (A12)
/IO Expander B/IOX_B_AGC-T2: C30.1, SW10.B, U1.27 (A13)
/IO Expander B/IOX_B_HIGH_WIDTH1: C31.1, SW9.A, U1.15 (A1)
/IO Expander B/IOX_B_HIGH_WIDTH2: C29.1, SW9.B, U1.14 (A0)
/IO Expander B/IOX_B_LOW_SHIFT1: C24.1, SW8.A, U1.17 (A3)
/IO Expander B/IOX_B_LOW_SHIFT2: C22.1, SW8.B, U1.16 (A2)
/IO Expander B/IOX_B_MUTE: C17.1, SW7.S1, U5.10 (GP0)
/IO Expander B/IOX_B_NB: C18.1, SW8.S1, U5.12 (GP2)
/IO Expander B/IOX_B_NR: C27.1, SW9.S1, U5.13 (GP3)
/IO Expander B/IOX_B_PhaseA: C25.1, J4.1, R3.2, U1.23 (A9)
/IO Expander B/IOX_B_PhaseB: C26.1, J4.5, R4.2, U1.22 (A8)
/IO Expander B/IOX_B_RIT: C19.1, S3.2, U5.14 (GP4)
/IO Expander B/IOX_B_RIT_SEL: C28.1, SW10.S1, U5.11 (GP1)
/IO Expander B/IOX_B_VOL1: C23.1, SW7.A, U1.21 (A7)
/IO Expander B/IOX_B_VOL2: C21.1, SW7.B, U1.20 (A6)
/IO Expander B/IOX_B_XIT: C20.1, S4.2, U5.15 (GP5)
/IO Expander B/PTT: C37.1, C39.1, J19.2, J20.2, U5.16 (GP6)
/IO Expander B/TUNE: C40.1, J21.2, U5.17 (GP7)
/IO Expander C/ACC_0: C56.1, J36.9, U7.21 (GPA0)
/IO Expander C/ACC_1: C57.1, J36.8, U7.22 (GPA1)
/IO Expander C/ACC_2: C58.1, J36.7, U7.23 (GPA2)
/IO Expander C/ACC_3: C59.1, J36.6, U7.24 (GPA3)
/IO Expander C/ACC_4: C60.1, J36.5, U7.25 (GPA4)
/IO Expander C/ACC_5: C61.1, J36.4, U7.26 (GPA5)
/IO Expander C/ACC_6: C62.1, J36.3, U7.27 (GPA6)
/IO Expander C/ACC_7: C63.1, J36.2, U7.28 (GPA7)
/IO Expander C/ACC_8: C50.1, J37.8, U7.7 (GPB6)
/IO Expander C/ACC_9: C49.1, J37.9, U7.8 (GPB7)
/IO Expander C/CW_MSG_1: C65.1, J37.2, U7.1 (GPB0)
/IO Expander C/CW_MSG_2: C64.1, J37.3, U7.2 (GPB1)
/IO Expander C/CW_MSG_3: C54.1, J37.4, U7.3 (GPB2)
/IO Expander C/CW_MSG_4: C53.1, J37.5, U7.4 (GPB3)
/IO Expander C/CW_MSG_5: C52.1, J37.6, U7.5 (GPB4)
/IO Expander C/CW_MSG_6: C51.1, J37.7, U7.6 (GPB5)
/Mic Profile/MIC_PROFILE: C55.1, J35.2, U1.36 (CS2)
/Microcontroller/CW_MIC_MENU1: C35.1, SW11.A, U1.28 (RX7)
/Microcontroller/CW_MIC_MENU2: C34.1, SW11.B, U1.29 (TX7)
/Microcontroller/DASH: C38.1, J22.1, U1.31 (CTX3)
/Microcontroller/DOT: C41.1, J22.3, U1.30 (CRX3)
/Microcontroller/KEYOUT: R6.2, U1.33 (MCLK2)
/Microcontroller/LCD_CS: U1.10 (CS1), U2.3 (~CS)
/Microcontroller/ON_OFF: C43.1, J26.2, U1.ON/OFF
/Microcontroller/PROGRAM: C44.1, J27.2, U1.PROGRAM
/Microcontroller/SIDE_TONE: J18.2, U1.34 (RX8)
/Microcontroller/ST_KEY: C36.1, J17.2, U1.32 (OUT1B)
/Microcontroller/TFT_DC: U1.9 (OUT1C), U2.5 (D/~C)
/Microcontroller/TFT_MISO: U1.12 (MISO), U2.9 (MISO), U2.13 (T_DO)
/Microcontroller/TFT_MOSI: U1.11 (MOSI), U2.6 (MOSI), U2.12 (T_DIN)
/Microcontroller/TFT_RST: U1.8 (TX2), U2.4 (RESET)
/Microcontroller/TFT_SCK: U1.13 (SCK), U2.7 (SCK), U2.10 (T_CLK)
/Microcontroller/TOUCH_CS: U1.37 (CS3), U2.11 (T_CS)
/Miscellaneous/OPTO_COL: J16.2, U3.4
/Miscellaneous/OPTO_EMM: J16.1, U3.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C43.2, C44.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, J2.2, J2.3, J4.2, J4.3, J17.1, J18.1, J19.1, J20.1, J21.1, J22.2, J26.1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
I2C_SCL: J28.4, R8.1, U1.19 (A5), U4.1 (SCL), U5.1 (SCL), U7.12 (SCK)
I2C_SDA: J28.3, R7.1, U1.18 (A4), U4.2 (SDA), U5.2 (SDA), U7.13 (SDA)
unnamed: R6.1, U3.1
unnamed: R5.1, U2.8 (LED)

File TeensyMaestro Main PCB/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C2, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C3, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C4, C40, C41, C43, C44, C46, C47, C48, C49, C5, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C6, C60, C61, C62, C63, C64, C65, C7, C8, C9",C_Disc_D5.0mm_W2.5mm_P5.00mm,63,100nF,
"H1, H2, H3, H4, H5, H6",MountingHole_2.5mm_Pad,6,MountingHole,
"J16, J17, J18, J19, J20, J21, J26, J27, J35",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,9,B2B-XH-A_LF__SN_,B2B-XH-A(LF)(SN)
"J2, J4",JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical,2,B5B-XH-A_LF__SN_,B5B-XH-A(LF)(SN)
J22,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,1,B3B-XH-A_LF__SN_,B3B-XH-A(LF)(SN)
J28,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,B4B-PH-K-S_LF__SN_,B4B-PH-K-S(LF)(SN)
"J36, J37",JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical,2,Conn_01x10,
"R1, R2, R3, R4",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,4,1K,
R5,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,100,
R6,R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical,1,1K,
"R7, R8",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,2,4K7,
"S1, S2, S3, S4",3ETH9120,4,1825910-6,1825910-6
SW10,PEC11L4115FS0020_NR,1,AGC-T/RIT_Sel A,
SW11,PEC11L4115FS0020,1,CW_Mic/Menu Sel,
SW2,PEC11L4115FS0020_NR,1,RotaryEncoder_Switch_MP,
SW3,PEC11L4115FS0020_NR,1,LowShift/NB A,
SW4,PEC11L4115FS0020_VNR,1,HighWidth/NR A,
SW5,PEC11L4115FS0020_VNR,1,AGC-T/RIT_Sel A,
SW7,PEC11L4115FS0020_VNR,1,Vol/Mute B,
SW8,PEC11L4115FS0020_VNR,1,LowShift/NB B,
SW9,PEC11L4115FS0020_NR,1,HighWidth/NR B,
TP1,TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded,1,5V,
TP2,TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded,1,3V3,
TP3,TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded,1,GND,
U1,MODULE_DEV-16771,1,DEV-16771,
U2,MSP4021-ST7796S-TM,1,MSP4021-ST7796S,
U3,DIP-4_W7.62mm,1,LTV-817,LTV-817
"U4, U5",DIP-18_W7.62mm,2,MCP23008-xP,
U7,DIP-28_W7.62mm_Socket_LongPads,1,MCP23017-E_SP,MCP23017-E/SP

## Commit log

2025-08-15 Create LICENSE
2025-08-30 Correct 8-pin to 10-pin
2025-09-07 Added image
2025-09-09 Updated README to reference Wiki
2025-09-09 Added images
2025-09-09 Added documentation images
2025-09-09 Updated documentation in schematic
2025-09-09 Regenerated ibom.html
2025-09-09 Regenerated schematic pdf
2025-11-09 Update schematic with 5v pullup correction
2025-11-09 Update schematic & BOM with 5v pullup correction
